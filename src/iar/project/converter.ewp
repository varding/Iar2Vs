# IAR project converter.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xC ST STM32F103xC
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: STM32F10X_HD; USE_STDPERIPH_DRIVER; USE_FULL_ASSERT
  ICCARM.CCIncludePath2: K:\product\pid\embed\pid_token\pub\st_lib\STM32F10x_StdPeriph_Driver; K:\product\pid\embed\pid_token\pub\st_lib\STM32F10x_StdPeriph_Driver\inc; K:\product\pid\embed\pid_token\pub\st_lib\startup; K:\product\pid\embed\pid_token\pub\base; K:\product\pid\embed\pid_token\pub\protocol; K:\product\pid\embed\pid_token\pub\driver
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 1
  OBJCOPY.OOCOutputFile: converter.bin
  ILINK.IlinkOutputFile: cpp.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xC.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; STM32F10X_HD; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: converter.hex
  ILINK.IlinkOutputFile: converter.out
  group pub
    ../boot/: main.cpp
  group pub/base
    ../pub/base/: crc32.c filter_task.cpp params.cpp print_task.cpp task_base.cpp
  group pub/base/test
    ../daq/src/: main.cpp
  group pub/driver
    ../pub/driver/: can.cpp led.c system.c usart_driver.cpp
  group pub/protocol
    ../pub/protocol/: message.cpp proto_buffer.cpp trans_task.cpp
  group pub/st_lib
    ../pub/st_lib/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group pub/startup
    ../pub/st_lib/startup/: startup_stm32f10x_hd.s system_stm32f10x.c
  group src
    src/: daq_ctrl_task.cpp forward_task.cpp main.cpp stm32f10x_it.c
  group src/w5500
    src/w5500/: socket.c w5500.c wizchip_conf.c
